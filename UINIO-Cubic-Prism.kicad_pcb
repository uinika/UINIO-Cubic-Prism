# Repository uinika/UINIO-Cubic-Prism

File README.md:

# UINIO-Cubic-Prism 分光棱镜展示器

一款基于 [**上海乐鑫科技 ESP32-PICO-D4**](https://products.espressif.com/) 微控制器的分光棱镜展示器。

## 工程目录说明

```
├─BOM                     电路原理图以及动态 BOM 文件
├─CAD                     3D 打印模型文件
│  ├─GCode                Cura 切片文件，仅适用于型号为 Vyper 的 3D 打印机
│  └─STL                  模型 STL 文件
├─Firmware                开源固件
├─Gerbers                 用于加工 PCB 电路板的光绘文件
├─Images                  README 图片素材
├─Libraries               KiCAD 原理图库、封装库、3D 模型库
│  ├─Uinika.3D
│  └─Uinio.Footprint
└─Tools                   固件烧写工具、屏幕共享工具、图片格式转换工具
```

## PCB 硬件电路

- 完全兼容 **Github** 上的 [HoloCubic_AIO](https://github.com/ClimbSnail/HoloCubic_AIO) 固件及其相关工具；
- 电路原理图进行了重绘，同时 PCB 也重新进行了手动布线，尽可能多的进行大面积铺铜；
- 天线屏蔽使用 2 排接地过孔（省略了阻抗匹配电路）；
- 同时提供 `AMS1117-3.3` 以及 `ME6211C33M5G` 两款线性稳压器芯片的屏幕显示模组方案，便于进行拼板打样；
- 更换了 TF 卡座为更加便宜并且比较容易购买的 封装形式；
- 屏幕扩展板和主板使用的稳压器芯片的 `3.3V` 完全隔离，多个稳压器并不能像其它开源的原理图当中那样，被简单的并联起来使用；
- 工程当中的 `Tools` 包含了常用的固件烧写、屏幕分享、图片转换工具；
- 主板与屏幕扩展板采用 `10cm` 长度的 `8Pin` 同向 FPC 软排线进行连接；

## CAD 外壳模型

项目当中的 `CAD` 目录，是为 **UINIO-CUBIC** 重新设计的外壳模型，以适配本项目的 PCB 尺寸；分光棱镜分别采用左右两个延伸柱进行固定，免去使用胶水粘结到屏幕上的麻烦。

CAD 模型分为上下两个部分（分别对应 FreeCAD 工程里的 `Base` 和 `Cover` 两个零件），分别用于安装**主板**与**屏幕扩展板**。

本 CAD 外壳模型分光棱镜的倾斜角度提升至 30 度，从而提升放置在桌面时的可视角度。并且将底部进行了掏空处理，提升主板的散热能力，同时也便于插拔 TF 卡。

RGB 发光二极管对应的外壳位置，专门进行了掏空处理，便于启动时观察其工作状态。左右两侧预留有 `2mm` 直径的沉头螺丝开孔以及相应的装饰盖（使用胶水粘接），可以根据 3D 打印出来的模型契合度按需进行使用。

## 固件与工具

|           名称           | 下载地址                                            | 描述                                |
| :----------------------: | :-------------------------------------------------- | :---------------------------------- |
|    **HoloCubic AIO**     | https://github.com/ClimbSnail/HoloCubic_AIO         | 兼容 UINIO-Cubic-Prism 的开源固件。 |
|  **HoloCubic AIO Tool**  | https://github.com/ClimbSnail/HoloCubic_AIO_Tool    | 固件烧录工具、图片与视频转换工具。  |
| **LVGL Image Converter** | https://github.com/W-Mai/lvgl_image_converter       | 基于 LVGL 的图片转换工具。          |
|    **ESP32 投屏工具**    | https://gitee.com/superddg123/esp32-TFT/tree/master | 运行在电脑上的 ESP32 投屏上位机。   |
|     **天气时钟 API**     | https://www.tianqiapi.com/                          | 内置的天气时钟 API 服务申请地址。   |

## KiCad design UINIO-Cubic-Prism.kicad_pcb

Parts:
C1, C4, C7, C8: 0.1uF; C_0402_1005Metric
C2, C10, C12, C13: 10uF; C_0402_1005Metric
C3, C5: 1uF; C_0402_1005Metric
C6, C9: 10nF; C_0402_1005Metric
C11: 2.2nF; C_0402_1005Metric
Card1: TF_Card_02A; TF-SMD_TF-02
Q1, Q2: AO3415A; SOT-23-3_L2.9-W1.6-P1.90-LS2.9-BL
R1, R2, R3, R4, R7, R11: 10K; R_0402_1005Metric
R5, R6: 12K; R_0402_1005Metric
R8: 10k; R_0402_1005Metric
R9: 200R; R_0402_1005Metric
R10, R12: 1K; R_0402_1005Metric
U1: CP2102; QFN-28_L5.0-W5.0-P0.50-TL-EP3.3; MFG #1 SILICON LABS
U2: BH1750FVI; XDCR_BH1750FVI-TR; PARTREV D
U3, U9, U12: FPC-SMD_8P-0.5mm; FPC-SMD_8P-P0.5_C9900011879
U4: AN2051_2.4G; ANT-SMD_L5.0-W2.0
U5: ESP32_PICO_D4; QFN-48_L7.0-W7.0-P0.50-BL-EP5.4
U6, U14: CON_12Pin; ST7789-FPC-PAD
U7, U10: ME6211; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
U8: MPU6050; QFN-24_L4.0-W4.0-P0.50-BL-EP2.7
U11: RGB_WS2812B_5050
U13: AMS1117; SOT-223-4_L6.5-W3.5-P2.30-LS7.0-BR
USB1: USB_Type_C_16Pin; USB-C-SMD_TYPEC-304J-BCP16
VT1, VT2: S8050; SOT-23-3_L2.9-W1.6-P1.90-LS2.9-BL

Connections:
/BH_SCL: U2.6 (SCL), U5.13 (32K_XN), U8.23 (SCL)
/BH_SDA: U2.4 (SDA), U5.12 (32K_XP), U8.24 (SDA)
/CP_Rx: U1.25 (RXD), U5.41 (U0TXD)
/CP_Tx: R9.1, U5.40 (U0RXD)
/DC: U3.4, U5.22 (GPIO2), U6.7 (D/C), U9.5, U12.4, U14.7 (D/C)
/DTR: R5.1, U1.28 (DTR), VT2.2 (E)
/EN: C3.2, R11.2, U5.9 (CHIP_PU), VT1.3 (C)
/FLASH_CLK: U5.31 (SD_CLK(FLASH_CLK))
/FLASH_CS: U5.25 (IO16(FLASH_CS))
/FLASH_SD0: U5.27 (IO17(FLASH_SD0))
/FLASH_SD1: U5.33 (SD_DATA_1(FLASH_SD1))
/FLASH_SD2: U5.30 (SD_CMD(FLASH_SD2))
/FLASH_SD3: U5.32 (SD_DATA_0(FLASH_SD3))
/GPIO0: U5.23 (GPIO0), VT2.3 (C)
/GPIO4: U3.7, U5.24 (GPIO4), U6.11 (RES), U9.2, U12.7, U14.11 (RES)
/GPIO5: R10.2, R12.2, U3.8, U5.34 (GPIO5), U9.1, U12.8
/GPIO9: U5.28 (SD_DATA_2/IO9)
/GPIO10: U5.29 (SD_DATA_3/IO10)
/GPIO12: U5.18 (MTDI)
/GPIO13: Card1.3 (CMD), R2.2, U5.20 (MTCK)
/GPIO14: Card1.5 (CLK), R3.2, U5.17 (MTMS)
/GPIO15: Card1.2 (CD/DAT3), R4.2, U5.21 (MTDO)
/GPIO18: U3.5, U5.35 (GPIO18), U6.9 (SCL), U9.4, U12.5, U14.9 (SCL)
/GPIO19: U5.38 (GPIO19)
/GPIO21: U5.42 (GPIO21)
/GPIO22: U5.39 (GPIO22)
/GPIO23: U3.6, U5.36 (GPIO23), U6.10 (SDA), U9.3, U12.6, U14.10 (SDA)
/GPIO25: U5.14 (GPIO25)
/GPIO26: Card1.7 (DAT0), R1.2, U5.15 (GPIO26)
/GPIO27: U5.16 (GPIO27), U11.4 (DIN)
/GPIO34: U5.10 (VDET_1)
/GPIO35: U5.11 (VDET_2)
/GPIO37: U5.6 (SENSOR_CAPP)
/GPIO38: U5.7 (SENSOR_CAPN)
/LCD_BL_VCC: Q1.3 (D), Q2.3 (D), U6.3 (LEDA), U14.3 (LEDA)
/RTS: R6.1, U1.24 (RTS), VT1.2 (E)
/SENSOR_VN: U5.8 (SENSOR_VN)
/SENSOR_VP: U5.5 (SENSOR_VP)
/USB_Data_N: U1.5 (D-), USB1.A7 (DN1), USB1.B7 (DN2)
/USB_Data_P: U1.4 (D+), USB1.A6 (DP1), USB1.B6 (DP2)
/VDD_3.3V: C1.1, C2.2, C4.2, C5.2, C6.1, C8.2, C10.2, C13.1, Card1.4 (VDD), Q1.2 (S), Q2.2 (S), R1.1, R2.1, R3.1, R4.1, R8.2, R11.1, U2.1 (VCC), U5.1 (VDDA), U5.3 (VDD3P3), U5.4 (VDD3P3), U5.19 (VDD3P3_RTC), U5.37 (VDD3P3_CPU), U5.43 (VDDA), U5.46 (VDDA), U6.4 (VDD), U7.5 (Vout), U8.8 (VLogic), U8.13 (VDD), U9.7, U10.5 (Vout), U13.2 (Vout), U13.4 (Vout), U14.4 (VDD)
/VDD_5V: C12.1, R7.1, U1.7 (REGIN), U1.8 (VBUS), U3.1, U7.1 (Vin), U7.3 (CE), U9.8, U10.1 (Vin), U10.3 (CE), U11.1 (VCC), U12.1, U13.3 (Vin), USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
GND: C1.2, C2.1, C3.1, C4.1, C5.1, C6.2, C7.2, C8.1, C9.1, C10.1, C11.1, C12.2, C13.2, Card1.6 (VSS), Card1.10 (GND), Card1.11 (GND), Card1.12 (GND), Card1.13 (GND), U1.3 (GND), U1.29 (HEAT_TAB), U2.2 (ADDR), U2.3 (GND), U3.3, U5.49 (GND), U6.1 (GND), U6.2 (LEDK), U6.5 (GND), U6.6 (GND), U6.8 (CS), U6.12 (GND), U7.2 (Vss), U8.1 (CLKIN), U8.9 (AD0), U8.11 (FSYNC), U8.18 (GND), U9.6, U10.2 (Vss), U11.3 (GND), U12.3, U13.1 (GND), U14.1 (GND), U14.2 (LEDK), U14.5 (GND), U14.6 (GND), U14.8 (CS), U14.12 (GND), USB1.13 (GND), USB1.14 (GND), USB1.15 (GND), USB1.16 (GND), USB1.A1B12 (GND), USB1.B1A12 (GND)
unnamed: C7.1, U8.10 (REGOUT)
unnamed: C9.2, U7.4 (NC)
unnamed: C11.2, U8.20 (CPOUT)
unnamed: Q1.1 (G), R10.1
unnamed: Q2.1 (G), R12.1
unnamed: R5.2, VT1.1 (B)
unnamed: R6.2, VT2.1 (B)
unnamed: R7.2, U1.9 (*RST)
unnamed: R8.1, U2.5 (DVI)
unnamed: R9.2, U1.26 (TXD)
unnamed: U4.1 (ANT), U5.2 (LNA_IN)

Notes on the sheet:
TF 存储卡插槽
AUTO PROGRAM CIRCUIT DTR RTS RST GPIO0 1 1 1 1 0 0 1 1 1 0 0 1 0 1 1 0
WS2812B RGB 发光二极管
USB 串口下载电路
ME6211 方案 ST7789 扩展板
AMS1117 方案 ST7789 扩展板
ME6211 线性稳压器
液晶屏连接器 & GPIO 映射
MPU6050 加速度传感器
BH1750 光线传感器
ESP32 PICO D4 微控制器

Board: 2 copper layers, 87.2 x 35.9 mm, 45 parts (5 on the bottom side), 35 nets.

## Commit log

2022-11-23 Release UINIO-Cubic-Prism 2.0.0.
2023-01-29 Release UINIO-Cubic-Prism version 3.0.0.
